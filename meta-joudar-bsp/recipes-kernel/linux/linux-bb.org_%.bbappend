FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
#SRC_URI += "file://mon_patch.patch"
COMPATIBLE_MACHINE:append = "|joudar-beagleboneblack"