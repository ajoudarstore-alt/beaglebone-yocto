LICENSE = "CLOSED"

SRC_URI = "file://joudar.dts"

inherit devicetree