LICENSE = "CLOSED"

SRC_URI = "\
    file://joudar.c \
    file://Makefile \
"

S = "${WORKDIR}"

inherit module