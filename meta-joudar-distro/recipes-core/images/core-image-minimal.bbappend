inherit extrausers
EXTRA_USERS_PARAMS := "usermod -p '$6$abc123$XXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXXX' root"
